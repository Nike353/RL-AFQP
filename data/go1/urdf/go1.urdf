Commit message: added pseudo adaptation

File: data/go1/urdf/go1.urdf (robot description, URDF)
Before this commit: robot go1, 34 links, 33 joints
Links:
- link trunk: mass 5.204 -> 2.204
